# Keil uVision project WirelessModule_APP.uvprojx, settings and files
target WirelessModule_APP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F150K8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.1.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WirelessModule_APP +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F130_150,STM32F10X_MD
  c include: ..\Project;..\..\Library\CMSIS\Include;..\..\Library\GD32F1x0_standard_peripheral\Source;..\..\Library\GD32F1x0_standard_peripheral\Include;..\..\Library\CMSIS\GD\GD32F1x0\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0xd800
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ./: main.c gd32f1x0_it.c systick.c usart.c usartapp.c rfid_cc1101.c rfid_driver.c wireless.c iapupdate.c
  group CMSIS
    ../../Library/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
  group GD32F1x0_Peripherals
    ../../Library/GD32F1x0_standard_peripheral/Source/: gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_gpio.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_usart.c gd32f1x0_wwdgt.c gd32f1x0_misc.c gd32f1x0_rcu.c gd32f1x0_fmc.c gd32f1x0_fwdgt.c
  group Startup
    ../../Library/CMSIS/GD/GD32F1x0/Source/ARM/: startup_gd32f1x0.s
  group Doc
    ./: readme.txt
